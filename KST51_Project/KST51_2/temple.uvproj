# Keil uVision project temple.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temple +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\USER
  group USER
    ./USER/: main.c
  group APP
    ./APP/: key.c time.c smg.c Lcd1602.c UART.c I2C.c EEPROM.c DS1302.c Delay.c ired.c DS18B20.c
