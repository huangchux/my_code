# Keil uVision project KST51_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: KST51_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\APP
  group USER
    ./USER/: main.c AllHead.h
  group APP
    ./APP/: Key.c SMG.c Time.c
