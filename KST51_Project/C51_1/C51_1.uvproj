# Keil uVision project C51_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: C51_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\USER;.\USER\iic;.\USER\EEPROM;.\USER\time;.\USER\DS18B20;.\USER\DS1302;.\USER\ired
  group USER
    ./USER/: main.c LED.c Delay.c BEEP.c smg.c key.c hc595.c step_motor.c EXTI.c uart.c
    ./USER/iic/: iic.c
    ./USER/EEPROM/: EEPROM.c
    ./USER/time/: time.c
    ./USER/DS18B20/: ds18b20.c
    ./USER/DS1302/: ds1302.c
    ./USER/ired/: ired.c
