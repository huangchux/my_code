# Keil uVision project temple.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temple +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\APP
  group USER
    ./USER/: main.c
  group APP
    ./APP/: LED.c smg.c
