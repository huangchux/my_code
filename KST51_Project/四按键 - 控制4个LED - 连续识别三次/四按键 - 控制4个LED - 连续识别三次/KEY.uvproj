# Keil uVision project KEY.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: KEY +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user\inc;C:\Keil_v5\C51\INC
  group Source Group 1
    ./: STARTUP.A51
    ./user/src/: main.c key.c delay.c
