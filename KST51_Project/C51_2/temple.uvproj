# Keil uVision project temple.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temple +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./USER/: main.c
